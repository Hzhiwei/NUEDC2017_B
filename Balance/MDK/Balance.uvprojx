# Keil uVision project Balance.uvprojx, settings and files
target Balance (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Balance
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,EMPL_TARGET_STM32F4,MPU6050,MPL_LOG_NDEBUG=1,EMPL,USE_DMP
  c misc: --C99
  c include: ..\algorithm\inc;..\bsp\inc;..\driver\inc;..\lib\core;..\lib\EMPL\driver\eMPL;..\lib\EMPL\driver\include;..\lib\EMPL\eMPL-hal;..\lib\EMPL\mllite;..\lib\EMPL\mpl;..\lib\freertos\inc;..\lib\std\inc;..\system\inc;..\task\inc;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.c stm32f4xx_it.c
  group driver
    ../driver/src/: driver_LED.c driver_mpu6050.c driver_steering.c driver_BallControl.c
  group task
    ../task/src/: task_SysInitConfig.c task_LEDFlash.c task_AngleControl.c task_UART1DMAReceive.c task_UART1DMASendData.c task_UART3DMAReceive.c task_BallControl.c task_HyperControl.c
  group bsp
    ../bsp/src/: BSP_EXIT.c BSP_GPIO.c BSP_TIM.c BSP_UART.c BSP_DMA.c
  group system
    ../system/src/: NVIC.c sim_IIC.c
  group EMPL
    ../lib/EMPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../lib/EMPL/driver/stm32L/: log.c
    ../lib/EMPL/eMPL-hal/: eMPL_outputs.c
    ../lib/EMPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group stdlib
    ../lib/std/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group freertos
    ../lib/freertos/src/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group core
    ../lib/core/: system_stm32f4xx.c startup_stm32f40_41xxx.s
