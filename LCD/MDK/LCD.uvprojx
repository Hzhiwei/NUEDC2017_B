# Keil uVision project LCD.uvprojx, settings and files
target LCD (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\algorithm\inc;..\bsp\inc;..\driver\inc;..\lib\core;..\lib\freertos\inc;..\lib\std\inc;..\system\inc;..\task\inc;..\user;..\UI\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.c stm32f4xx_it.c font.c
  group UI
    ../UI/inc/: UIDataStruction.h
    ../UI/src/: UI.c UICallBack.c UIButton.c UIControl.c UIIME.c UIPage.c UIDrawRAM.c UIPositioningPanel.c
  group driver
    ../driver/src/: driver_LCD5310.c driver_SRAM.c driver_UI.c driver_touch.c
  group task
    ../task/src/: task_SysInitConfig.c task_LCD5310Update.c task_TouchINT.c task_UARTDMASend.c task_UARTDMAReceive.c
  group bsp
    ../bsp/src/: BSP_EXIT.c BSP_GPIO.c BSP_TIM.c BSP_UART.c BSP_FSMC.c BSP_DMA.c
  group system
    ../system/src/: NVIC.c
  group stdlib
    ../lib/std/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group freertos
    ../lib/freertos/src/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group core
    ../lib/core/: system_stm32f4xx.c startup_stm32f40_41xxx.s
